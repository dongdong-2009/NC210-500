<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NC210-500&#x5De5;&#x51B5;&#x4Fe1;&#x53F7;&#x68C0;&#x6D4B;&#x677F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


